# Keil uVision project SK.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L130.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32_L2MAX +hex
  AfterMake: D:\晾衣机上位机\晾衣机上位机\SlaveConverter.exe "#H"
  AfterMake: D:\TEST_OTA\4合并boot_app_hex.bat
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\driver\inc;.\common;.\source;.\driver\inc;D:\keil5\Keil5 MDK541\ARM\CMSIS\6.1.0\CMSIS\Core\Include;.\MDK\RTE\__FEATURE__Release
  library: MicroLIB
  memory RVCT4: ROM 0x3000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group Config
    ./driver/src/: sysctrl.c
    ./common/: interrupts_hc32l13x.c system_hc32l13x.c
    ./: startup_hc32l13x.s
  group USER
    ./source/: main.c
    ./: systeam.c keelop_crc.c
  group Head
    ./driver/inc/: ALL_Var.h head_define.h head_function.h
  group Middleware
    ./driver/src/: spi.c lpuart.c timer3.c lpm.c wdt.c flash.c trim.c bgr.c adt.c adc.c bt.c lvd.c ddl.c uart.c gpio.c
  group Application
    ./BSP/: App_433_user.c app_asr.c app_moter.c app_buzzer.c app_wifi.c app_adc.c app_flash.c app_led_key.c
    ./: app_limit.c app_led.c
  group Interrupts
    ./BSP/: isr_port.c isr_timer.c isr_uart.c isr_adc.c
    ./: isr_lvd.c
  group Drivers
    ./BSP/: dri_led_key.c dri_timer.c dri_spi.c dri_uart.c dri_adc.c dri_lvd.c
  group README
    ./: readme.txt
software components: CMSIS:CORE 6.1.1
